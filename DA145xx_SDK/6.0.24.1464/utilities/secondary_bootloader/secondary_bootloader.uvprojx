# Keil uVision project secondary_bootloader.uvprojx, settings and files
target DA14585 (6180000::V6.18::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: secondary_bootloader_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __NON_BLE_EXAMPLE__ STACK_TOP_IS_THE_RAM_END
  c misc: -mthumb -c -include da1458x_config_basic.h
  c include: .\includes;..\..\sdk\platform\include;..\..\sdk\platform\driver\spi;..\..\sdk\platform\driver\i2c_eeprom;..\..\sdk\platform\driver\i2c;..\..\sdk\platform\driver\spi_flash;..\..\sdk\platform\driver\gpio;..\..\sdk\platform\driver\dma;..\..\sdk\platform\arch;..\..\sdk\platform\arch\compiler;..\..\sdk\platform\arch\ll;..\..\sdk\platform\driver\reg;..\..\sdk\platform\driver\syscntl;..\..\sdk\platform\driver\uart;..\..\sdk\platform\driver\timer;..\..\sdk\platform\core_modules\crypto;..\..\sdk\platform\driver\systick;..\..\sdk\platform\driver\hw_otpc;..\..\sdk\platform\arch\main;..\..\sdk\platform\core_modules\nvds\api;..\..\sdk\platform\utilities\otp_hdr;..\..\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core\Include;..\..\sdk\platform\system_library\include;..\..\sdk\platform\uecc_patch_library\include;..\..\sdk\platform\utilities\otp_key_storage;..\..\sdk\platform\utilities\otp_utils;..\..\third_party\sha2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\bootloader_585_armclang.sct
  link misc: .\..\..\sdk\common_project_files\misc\da14585_for_sec_boot.txt --any_placement=best_fit --datacompressor off
--userlibpath ..\..\sdk\platform\system_library\output\Keil_5\ da14585_586.lib --userlibpath ..\..\sdk\platform\uECC_patch_library\output\Keil_5\ uecc_patch.lib
  group boot
    ../../sdk/platform/arch/boot/: system_DA14585_586.c startup_DA14585_586.c system_DA14531.c startup_DA14531.c system_DA14535.c startup_DA14535.c
    ../../sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group src
    ./src/: bootloader.c main.c uart_booter.c decrypt.c user_periph_setup.c ecc_verify.c
    ../../sdk/platform/driver/spi_flash/: spi_flash.c
    ../../sdk/platform/driver/gpio/: gpio.c
    ../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ../../third_party/crc32/: crc32.c
    ../../sdk/platform/core_modules/crypto/: sw_aes.c
    ../../sdk/platform/driver/dma/: dma.c
    ../../sdk/platform/driver/spi/: spi_58x.c spi_531.c
    ../../sdk/platform/driver/i2c/: i2c.c
    ../../sdk/platform/driver/uart/: uart.c
    ../../sdk/platform/driver/systick/: systick.c
    ../../sdk/platform/driver/syscntl/: syscntl.c
    ../../sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    ../../sdk/platform/utilities/otp_cs/: otp_cs.c
    ../../sdk/platform/arch/main/: arch_system.c
    ../../sdk/platform/arch/fpga/: fpga.c
    ../../third_party/sha2/: sha2.c
    ../../sdk/platform/utilities/otp_key_storage/: key_storage.c
    ../../sdk/platform/utilities/otp_utils/: otp_utils.c
  group da14585-6_includes
    ./includes/: da14585_config_basic.h
  group da14531_includes
    ./includes/: da14531_config_basic.h
  group da14535_includes
    ./includes/: da14535_config_basic.h
  group includes
    ./includes/: user_periph_setup.h uart_booter.h bootloader.h da1458x_config_basic.h ecc_verify.h
    ../../sdk/platform/include/: datasheet.h sdk_defs.h
    ../../sdk/platform/driver/spi/: spi.h
    ../../sdk/platform/driver/spi_flash/: spi_flash.h
    ../../sdk/platform/driver/gpio/: gpio.h
    ../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    ../../sdk/platform/core_modules/crypto/: sw_aes.h
    ../../sdk/platform/driver/uart/: uart.h
    ../../third_party/sha2/: sha2.h
    ../../sdk/platform/utilities/otp_utils/: otp_utils.h
    ../../sdk/platform/utilities/otp_key_storage/: key_storage.h
target DA14586 (6180000::V6.18::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: secondary_bootloader_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14586\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14586__ __NON_BLE_EXAMPLE__ STACK_TOP_IS_THE_RAM_END
  c misc: -mthumb -c -include da1458x_config_basic.h
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\bootloader_585_armclang.sct
  link misc: as above
target DA14531 (6180000::V6.18::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: secondary_bootloader_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14531__  __NON_BLE_EXAMPLE__ STACK_TOP_IS_THE_RAM_END
  c misc: -mthumb -c -include da1458x_config_basic.h
  c include: .\includes;..\..\sdk\platform\include;..\..\sdk\platform\driver\spi;..\..\sdk\platform\driver\i2c_eeprom;..\..\sdk\platform\driver\i2c;..\..\sdk\platform\driver\spi_flash;..\..\sdk\platform\driver\gpio;..\..\sdk\platform\driver\dma;..\..\sdk\platform\arch;..\..\sdk\platform\arch\compiler;..\..\sdk\platform\arch\ll;..\..\sdk\platform\driver\reg;..\..\sdk\platform\driver\syscntl;..\..\sdk\platform\driver\uart;..\..\sdk\platform\driver\timer;..\..\sdk\platform\core_modules\crypto;..\..\sdk\platform\driver\systick;..\..\sdk\platform\driver\hw_otpc;..\..\sdk\platform\utilities\otp_cs;..\..\sdk\platform\driver\adc;..\..\sdk\platform\core_modules\rf\api;..\..\sdk\platform\arch\main;..\..\sdk\platform\core_modules\nvds\api;..\..\sdk\platform\utilities\otp_hdr;..\..\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core\Include;..\..\sdk\platform\system_library\include;..\..\sdk\platform\uecc_patch_library\include;..\..\sdk\platform\utilities\otp_key_storage;..\..\sdk\platform\utilities\otp_utils;..\..\third_party\sha2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\bootloader_531_armclang.sct
  link misc: .\..\..\sdk\common_project_files\misc\da14531_for_sec_boot.txt --any_placement=best_fit --datacompressor off
--userlibpath ..\..\sdk\platform\system_library\output\Keil_5\ da14531.lib --userlibpath ..\..\sdk\platform\uECC_patch_library\output\Keil_5\ uecc_patch.lib
target DA14531_01 (6180000::V6.18::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: secondary_bootloader_531_01 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531_01\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14531__  __DA14531_01__ __NON_BLE_EXAMPLE__ __EXCLUDE_ROM_SPI_531__ STACK_TOP_IS_THE_RAM_END
  c misc: -mthumb -c -include da1458x_config_basic.h
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\bootloader_531_armclang.sct
  link misc: .\..\..\sdk\common_project_files\misc\da14531_01_for_sec_boot.txt --any_placement=best_fit --datacompressor off
--userlibpath ..\..\sdk\platform\system_library\output\Keil_5\ da14531_01.lib --userlibpath ..\..\sdk\platform\uECC_patch_library\output\Keil_5\ uecc_patch.lib
target DA14535 (6180000::V6.18::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: secondary_bootloader_535 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14535\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14531__  __DA14535__ __NON_BLE_EXAMPLE__ __EXCLUDE_ROM_SPI_531__ STACK_TOP_IS_THE_RAM_END
  c misc: -mthumb -c -include da1458x_config_basic.h
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\bootloader_535_armclang.sct
  link misc: .\..\..\sdk\common_project_files\misc\da14535_for_sec_boot.txt --any_placement=best_fit --datacompressor off
--userlibpath ..\..\sdk\platform\system_library\output\Keil_5\ da14535.lib --userlibpath ..\..\sdk\platform\uECC_patch_library\output\Keil_5\ uecc_patch.lib
