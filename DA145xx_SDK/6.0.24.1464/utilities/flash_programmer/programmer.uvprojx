# Keil uVision project programmer.uvprojx, settings and files
target DA14585_jtag (6180000::V6.18::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: jtag_programmer_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585_JTAG\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __NON_BLE_EXAMPLE__ STACK_TOP_IS_THE_RAM_END
  c misc: -mthumb -c -include da1458x_config_basic.h
  c include: .\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\sdk\platform\driver\i2c;.\..\..\sdk\platform\driver\spi;.\..\..\sdk\platform\driver\dma;.\..\..\sdk\platform\arch;.\..\..\sdk\platform\arch\compiler;.\..\..\sdk\platform\arch\ll;.\..\..\sdk\platform\driver\reg;.\..\..\sdk\platform\include;.\include;.\..\..\sdk\platform\driver\gpio;.\..\..\sdk\platform\driver\spi_flash;.\..\..\sdk\platform\core_modules\rwip\api;.\..\..\sdk\platform\driver\hw_otpc;.\..\..\sdk\platform\driver\uart;.\..\..\sdk\platform\driver\syscntl;.\..\..\sdk\platform\driver\timer;.\..\..\sdk\platform\utilities\otp_hdr;.\..\..\sdk\platform\utilities\otp_utils;.\..\..\sdk\platform\utilities\otp_key_storage;.\..\..\sdk\platform\arch\main;.\..\..\sdk\platform\core_modules\nvds\api;..\..\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core\Include;..\..\sdk\platform\system_library\include
  library: MicroLIB
  memory RVCT4: ROM 0x80000 size 0x1b00
  memory RVCT9: RAM 0x81b00 size 0x500
  scatter file: .\startup\programmer_585_jtag_armclang.sct
  link misc: --any_placement=best_fit --datacompressor off
--userlibpath ..\..\sdk\platform\system_library\output\Keil_5\ da14585_586.lib
  group Startup Files
    ../../sdk/platform/arch/boot/: system_DA14585_586.c startup_DA14585_586.c system_DA14531.c startup_DA14531.c system_DA14535.c startup_DA14535.c
    ../../sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group Source Files
    ./src/: peripherals.c programmer.c
    ../../third_party/crc32/: crc32.c
    ./../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ./../../sdk/platform/driver/spi_flash/: spi_flash.c
    ./../../sdk/platform/driver/gpio/: gpio.c
    ../../sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    ../../sdk/platform/driver/dma/: dma.c
    ../../sdk/platform/driver/spi/: spi_58x.c spi_531.c
    ../../sdk/platform/driver/i2c/: i2c.c
    ../../sdk/platform/driver/uart/: uart.c
    ../../sdk/platform/driver/syscntl/: syscntl.c
    ../../sdk/platform/driver/timer/: timer0.c
    ../../sdk/platform/arch/main/: arch_system.c
    ../../sdk/platform/utilities/otp_cs/: otp_cs.c
    ../../sdk/platform/utilities/otp_utils/: otp_utils.c
  group Include Files
    ./include/: user_periph_setup.h programmer.h version.h da1458x_config_basic.h
    ./../../sdk/platform/driver/gpio/: gpio.h
    ./../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    ./../../sdk/platform/driver/spi/: spi.h
    ./../../sdk/platform/driver/spi_flash/: spi_flash.h
    ../../sdk/platform/driver/hw_otpc/: hw_otpc.h
    ../../sdk/platform/utilities/otp_key_storage/: key_storage_defs.h
    ../../sdk/platform/utilities/otp_utils/: otp_utils.h
target DA14585_uart (6180000::V6.18::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: flash_programmer_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585_UART\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: USE_UART __NON_BLE_EXAMPLE__ STACK_TOP_IS_THE_RAM_END
  c misc: -mthumb -c -include da1458x_config_basic.h
  c include: .\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\sdk\platform\driver\i2c;.\..\..\sdk\platform\driver\spi;.\..\..\sdk\platform\driver\dma;.\..\..\sdk\platform\arch;.\..\..\sdk\platform\arch\compiler;.\..\..\sdk\platform\arch\ll;.\..\..\sdk\platform\driver\reg;.\..\..\sdk\platform\include;.\include;.\..\..\sdk\platform\driver\gpio;.\..\..\sdk\platform\driver\spi_flash;.\..\..\sdk\platform\core_modules\rwip\api;.\..\..\sdk\platform\driver\hw_otpc;.\..\..\sdk\platform\driver\uart;.\..\..\sdk\platform\driver\syscntl;.\..\..\sdk\platform\driver\timer;.\..\..\sdk\platform\utilities\otp_hdr;.\..\..\sdk\platform\utilities\otp_utils;.\..\..\sdk\platform\utilities\otp_key_storage;.\..\..\sdk\platform\core_modules\nvds\api;.\..\..\sdk\platform\arch\main;..\..\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core\Include;..\..\sdk\platform\system_library\include
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xa000
  scatter file: .\startup\programmer_585_uart_armclang.sct
  link misc: as above
target DA14531_jtag (6180000::V6.18::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: jtag_programmer_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531_JTAG\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14531__ __NON_BLE_EXAMPLE__ STACK_TOP_IS_THE_RAM_END
  c misc: -mthumb -c -include da1458x_config_basic.h
  c include: .\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\sdk\platform\driver\i2c;.\..\..\sdk\platform\driver\spi;.\..\..\sdk\platform\driver\dma;.\..\..\sdk\platform\arch;.\..\..\sdk\platform\arch\compiler;.\..\..\sdk\platform\arch\ll;.\..\..\sdk\platform\driver\reg;.\..\..\sdk\platform\include;.\include;.\..\..\sdk\platform\driver\gpio;.\..\..\sdk\platform\driver\spi_flash;.\..\..\sdk\platform\core_modules\rwip\api;.\..\..\sdk\platform\driver\hw_otpc;.\..\..\sdk\platform\driver\uart;.\..\..\sdk\platform\driver\syscntl;.\..\..\sdk\platform\utilities\otp_hdr;.\..\..\sdk\platform\driver\timer;.\..\..\sdk\platform\driver\adc;.\..\..\sdk\platform\arch\main;.\..\..\sdk\platform\core_modules\nvds\api;.\..\..\sdk\platform\utilities\otp_cs;.\..\..\sdk\platform\utilities\otp_utils;.\..\..\sdk\platform\utilities\otp_key_storage;.\..\..\sdk\platform\core_modules\rf\api;..\..\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core\Include;..\..\sdk\platform\system_library\include
  asm define: STACK_SIZE=0x600
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\programmer_531_jtag_armclang.sct
  link misc: --any_placement=best_fit --datacompressor off
--userlibpath ..\..\sdk\platform\system_library\output\Keil_5\ da14531.lib
target DA14531_uart (6180000::V6.18::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: flash_programmer_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531_UART\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14531__ USE_UART CFG_UART_ONE_WIRE_SUPPORT __NON_BLE_EXAMPLE__ STACK_TOP_IS_THE_RAM_END
  c misc: -mthumb -c -include da1458x_config_basic.h
  c include: .\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\sdk\platform\driver\i2c;.\..\..\sdk\platform\driver\spi;.\..\..\sdk\platform\driver\dma;.\..\..\sdk\platform\arch;.\..\..\sdk\platform\arch\compiler;.\..\..\sdk\platform\arch\ll;.\..\..\sdk\platform\driver\reg;.\..\..\sdk\platform\include;.\include;.\..\..\sdk\platform\driver\gpio;.\..\..\sdk\platform\driver\spi_flash;.\..\..\sdk\platform\core_modules\rwip\api;.\..\..\sdk\platform\driver\hw_otpc;.\..\..\sdk\platform\driver\uart;.\..\..\sdk\platform\driver\syscntl;.\..\..\sdk\platform\utilities\otp_hdr;.\..\..\sdk\platform\driver\timer;.\..\..\sdk\platform\driver\adc;.\..\..\sdk\platform\arch\main;.\..\..\sdk\platform\core_modules\nvds\api;.\..\..\sdk\platform\core_modules\rf\api;.\..\..\sdk\platform\utilities\otp_cs;.\..\..\sdk\platform\utilities\otp_utils;.\..\..\sdk\platform\utilities\otp_key_storage;..\..\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core\Include;..\..\sdk\platform\system_library\include
  asm define: STACK_TOP_IS_THE_RAM_END
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\programmer_531_uart_armclang.sct
  link misc: as above
target DA14531_01_jtag (6180000::V6.18::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: jtag_programmer_531_01 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531_01_JTAG\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14531__ __DA14531_01__ __NON_BLE_EXAMPLE__ STACK_TOP_IS_THE_RAM_END
  c misc: -mthumb -c -include da1458x_config_basic.h
  c include: as above
  asm define: STACK_SIZE=0x600
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\programmer_531_jtag_armclang.sct
  link misc: --any_placement=best_fit --datacompressor off .\..\..\sdk\common_project_files\misc\da14531_01_for_periph.txt
--userlibpath ..\..\sdk\platform\system_library\output\Keil_5\ da14531_01.lib
target DA14531_01_uart (6180000::V6.18::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: flash_programmer_531_01 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531_01_UART\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14531__ __DA14531_01__ USE_UART CFG_UART_ONE_WIRE_SUPPORT __NON_BLE_EXAMPLE__ STACK_TOP_IS_THE_RAM_END
  c misc: -mthumb -c -include da1458x_config_basic.h
  c include: as above
  asm define: STACK_TOP_IS_THE_RAM_END
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\programmer_531_uart_armclang.sct
  link misc: as above
target DA14535_jtag (6180000::V6.18::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: jtag_programmer_535 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14535_JTAG\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14531__ __DA14535__ __NON_BLE_EXAMPLE__ STACK_TOP_IS_THE_RAM_END
  c misc: -mthumb -c -include da1458x_config_basic.h
  c include: as above
  asm define: STACK_SIZE=0x600
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\programmer_535_jtag_armclang.sct
  link misc: --any_placement=best_fit --datacompressor off .\..\..\sdk\common_project_files\misc\da14535_for_periph.txt
--userlibpath ..\..\sdk\platform\system_library\output\Keil_5\ da14535.lib
target DA14535_uart (6180000::V6.18::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: flash_programmer_535 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14535_UART\Objects\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __DA14531__ __DA14535__ USE_UART CFG_UART_ONE_WIRE_SUPPORT __NON_BLE_EXAMPLE__ STACK_TOP_IS_THE_RAM_END
  c misc: -mthumb -c -include da1458x_config_basic.h
  c include: as above
  asm define: STACK_TOP_IS_THE_RAM_END
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\programmer_535_uart_armclang.sct
  link misc: as above
