# IAR project prox_reporter.ewp, settings and files
configuration DA14585 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.PreInclude: preinclude.h
  ICCARM.CCIncludePath2: ..\..\..\..\..\sdk\app_modules\api; ..\..\..\..\..\sdk\ble_stack\controller\em; ..\..\..\..\..\sdk\ble_stack\controller\llc; ..\..\..\..\..\sdk\ble_stack\controller\lld; ..\..\..\..\..\sdk\ble_stack\controller\llm; ..\..\..\..\..\sdk\ble_stack\ea\api; ..\..\..\..\..\sdk\ble_stack\em\api; ..\..\..\..\..\sdk\ble_stack\hci\api; ..\..\..\..\..\sdk\ble_stack\hci\src; ..\..\..\..\..\sdk\ble_stack\host\att; ..\..\..\..\..\sdk\ble_stack\host\att\attc; ..\..\..\..\..\sdk\ble_stack\host\att\attm; ..\..\..\..\..\sdk\ble_stack\host\att\atts; ..\..\..\..\..\sdk\ble_stack\host\gap; ..\..\..\..\..\sdk\ble_stack\host\gap\gapc; ..\..\..\..\..\sdk\ble_stack\host\gap\gapm; ..\..\..\..\..\sdk\ble_stack\host\gatt; ..\..\..\..\..\sdk\ble_stack\host\gatt\gattc; ..\..\..\..\..\sdk\ble_stack\host\gatt\gattm; ..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc; ..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm; ..\..\..\..\..\sdk\ble_stack\host\smp; ..\..\..\..\..\sdk\ble_stack\host\smp\smpc; ..\..\..\..\..\sdk\ble_stack\host\smp\smpm; ..\..\..\..\..\sdk\ble_stack\profiles; ..\..\..\..\..\sdk\ble_stack\profiles\anc; ..\..\..\..\..\sdk\ble_stack\profiles\anc\ancc\api; ..\..\..\..\..\sdk\ble_stack\profiles\anp; ..\..\..\..\..\sdk\ble_stack\profiles\anp\anpc\api; ..\..\..\..\..\sdk\ble_stack\profiles\anp\anps\api; ..\..\..\..\..\sdk\ble_stack\profiles\bas\basc\api; ..\..\..\..\..\sdk\ble_stack\profiles\bas\bass\api; ..\..\..\..\..\sdk\ble_stack\profiles\bcs; ..\..\..\..\..\sdk\ble_stack\profiles\bcs\bcsc\api; ..\..\..\..\..\sdk\ble_stack\profiles\bcs\bcss\api; ..\..\..\..\..\sdk\ble_stack\profiles\blp; ..\..\..\..\..\sdk\ble_stack\profiles\blp\blpc\api; ..\..\..\..\..\sdk\ble_stack\profiles\blp\blps\api; ..\..\..\..\..\sdk\ble_stack\profiles\bms; ..\..\..\..\..\sdk\ble_stack\profiles\bms\bmsc\api; ..\..\..\..\..\sdk\ble_stack\profiles\bms\bmss\api; ..\..\..\..\..\sdk\ble_stack\profiles\cpp; ..\..\..\..\..\sdk\ble_stack\profiles\cpp\cppc\api; ..\..\..\..\..\sdk\ble_stack\profiles\cpp\cpps\api; ..\..\..\..\..\sdk\ble_stack\profiles\cscp; ..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscpc\api; ..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscps\api; ..\..\..\..\..\sdk\ble_stack\profiles\cts; ..\..\..\..\..\sdk\ble_stack\profiles\cts\ctsc\api; ..\..\..\..\..\sdk\ble_stack\profiles\cts\ctss\api; ..\..\..\..\..\sdk\ble_stack\profiles\custom; ..\..\..\..\..\sdk\ble_stack\profiles\custom\custs\api; ..\..\..\..\..\sdk\ble_stack\profiles\dis\disc\api; ..\..\..\..\..\sdk\ble_stack\profiles\dis\diss\api; ..\..\..\..\..\sdk\ble_stack\profiles\find; ..\..\..\..\..\sdk\ble_stack\profiles\find\findl\api; ..\..\..\..\..\sdk\ble_stack\profiles\find\findt\api; ..\..\..\..\..\sdk\ble_stack\profiles\gatt\gatt_client\api; ..\..\..\..\..\sdk\ble_stack\profiles\glp; ..\..\..\..\..\sdk\ble_stack\profiles\glp\glpc\api; ..\..\..\..\..\sdk\ble_stack\profiles\glp\glps\api; ..\..\..\..\..\sdk\ble_stack\profiles\hogp; ..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpbh\api; ..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpd\api; ..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogprh\api; ..\..\..\..\..\sdk\ble_stack\profiles\hrp; ..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrpc\api; ..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrps\api; ..\..\..\..\..\sdk\ble_stack\profiles\htp; ..\..\..\..\..\sdk\ble_stack\profiles\htp\htpc\api; ..\..\..\..\..\sdk\ble_stack\profiles\htp\htpt\api; ..\..\..\..\..\sdk\ble_stack\profiles\lan; ..\..\..\..\..\sdk\ble_stack\profiles\lan\lanc\api; ..\..\..\..\..\sdk\ble_stack\profiles\lan\lans\api; ..\..\..\..\..\sdk\ble_stack\profiles\pasp; ..\..\..\..\..\sdk\ble_stack\profiles\pasp\paspc\api; ..\..\..\..\..\sdk\ble_stack\profiles\pasp\pasps\api; ..\..\..\..\..\sdk\ble_stack\profiles\prox\proxm\api; ..\..\..\..\..\sdk\ble_stack\profiles\prox\proxr\api; ..\..\..\..\..\sdk\ble_stack\profiles\rscp; ..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscpc\api; ..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscps\api; ..\..\..\..\..\sdk\ble_stack\profiles\scpp; ..\..\..\..\..\sdk\ble_stack\profiles\scpp\scppc\api; ..\..\..\..\..\sdk\ble_stack\profiles\scpp\scpps\api; ..\..\..\..\..\sdk\ble_stack\profiles\suota\suotar\api; ..\..\..\..\..\sdk\ble_stack\profiles\tip; ..\..\..\..\..\sdk\ble_stack\profiles\tip\tipc\api; ..\..\..\..\..\sdk\ble_stack\profiles\tip\tips\api; ..\..\..\..\..\sdk\ble_stack\profiles\uds; ..\..\..\..\..\sdk\ble_stack\profiles\uds\udsc\api; ..\..\..\..\..\sdk\ble_stack\profiles\uds\udss\api; ..\..\..\..\..\sdk\ble_stack\profiles\wss; ..\..\..\..\..\sdk\ble_stack\profiles\wss\wssc\api; ..\..\..\..\..\sdk\ble_stack\profiles\wss\wsss\api; ..\..\..\..\..\sdk\ble_stack\rwble; ..\..\..\..\..\sdk\ble_stack\rwble_hl; ..\..\..\..\..\sdk\common_project_files; ..\..\..\..\..\sdk\platform\arch; ..\..\..\..\..\sdk\platform\arch\boot; ..\..\..\..\..\sdk\platform\arch\boot\ARM; ..\..\..\..\..\sdk\platform\arch\boot\GCC; ..\..\..\..\..\sdk\platform\arch\compiler; ..\..\..\..\..\sdk\platform\arch\compiler\ARM; ..\..\..\..\..\sdk\platform\arch\compiler\GCC; ..\..\..\..\..\sdk\platform\arch\ll; ..\..\..\..\..\sdk\platform\arch\main; ..\..\..\..\..\sdk\platform\core_modules\arch_console; ..\..\..\..\..\sdk\platform\core_modules\common\api; ..\..\..\..\..\sdk\platform\core_modules\crypto; ..\..\..\..\..\sdk\platform\core_modules\dbg\api; ..\..\..\..\..\sdk\platform\core_modules\gtl\api; ..\..\..\..\..\sdk\platform\core_modules\gtl\src; ..\..\..\..\..\sdk\platform\core_modules\h4tl\api; ..\..\..\..\..\sdk\platform\core_modules\ke\api; ..\..\..\..\..\sdk\platform\core_modules\ke\src; ..\..\..\..\..\sdk\platform\core_modules\nvds\api; ..\..\..\..\..\sdk\platform\core_modules\rf\api; ..\..\..\..\..\sdk\platform\core_modules\rwip\api; ..\..\..\..\..\sdk\platform\driver\adc; ..\..\..\..\..\sdk\platform\driver\battery; ..\..\..\..\..\sdk\platform\driver\ble; ..\..\..\..\..\sdk\platform\driver\dma; ..\..\..\..\..\sdk\platform\driver\gpio; ..\..\..\..\..\sdk\platform\driver\hw_otpc; ..\..\..\..\..\sdk\platform\driver\i2c; ..\..\..\..\..\sdk\platform\driver\i2c_eeprom; ..\..\..\..\..\sdk\platform\driver\pdm; ..\..\..\..\..\sdk\platform\driver\reg; ..\..\..\..\..\sdk\platform\driver\rtc; ..\..\..\..\..\sdk\platform\driver\spi; ..\..\..\..\..\sdk\platform\driver\spi_flash; ..\..\..\..\..\sdk\platform\driver\spi_hci; ..\..\..\..\..\sdk\platform\driver\syscntl; ..\..\..\..\..\sdk\platform\driver\systick; ..\..\..\..\..\sdk\platform\driver\timer; ..\..\..\..\..\sdk\platform\driver\trng; ..\..\..\..\..\sdk\platform\driver\uart; ..\..\..\..\..\sdk\platform\driver\wkupct_quadec; ..\..\..\..\..\sdk\platform\include; ..\..\..\..\..\sdk\platform\system_library\include; ..\..\..\..\..\third_party\hash; ..\..\..\..\..\third_party\rand; ..\src; ..\src\config; ..\..\..\..\..\sdk\platform\utilities\otp_hdr
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: prox_reporter_585.bin
  ILINK.IlinkOutputFile: prox_reporter_585.out
  ILINK.IlinkIcfFile: da14585_586.icf
  ILINK.IlinkExtraOptions: -f ..\..\..\..\..\sdk\common_project_files\misc\da14585_symbols.xcl
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DA14586 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __DA14586__=
  OBJCOPY.OOCOutputFile: prox_reporter_586.bin
  ILINK.IlinkOutputFile: prox_reporter_586.out
configuration DA14531 (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 35
  ICCARM.CCDefines: __DA14531__=
  ICCARM.CCIncludePath2: ..\..\..\..\..\sdk\app_modules\api; ..\..\..\..\..\sdk\ble_stack\controller\em; ..\..\..\..\..\sdk\ble_stack\controller\llc; ..\..\..\..\..\sdk\ble_stack\controller\lld; ..\..\..\..\..\sdk\ble_stack\controller\llm; ..\..\..\..\..\sdk\ble_stack\ea\api; ..\..\..\..\..\sdk\ble_stack\em\api; ..\..\..\..\..\sdk\ble_stack\hci\api; ..\..\..\..\..\sdk\ble_stack\hci\src; ..\..\..\..\..\sdk\ble_stack\host\att; ..\..\..\..\..\sdk\ble_stack\host\att\attc; ..\..\..\..\..\sdk\ble_stack\host\att\attm; ..\..\..\..\..\sdk\ble_stack\host\att\atts; ..\..\..\..\..\sdk\ble_stack\host\gap; ..\..\..\..\..\sdk\ble_stack\host\gap\gapc; ..\..\..\..\..\sdk\ble_stack\host\gap\gapm; ..\..\..\..\..\sdk\ble_stack\host\gatt; ..\..\..\..\..\sdk\ble_stack\host\gatt\gattc; ..\..\..\..\..\sdk\ble_stack\host\gatt\gattm; ..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc; ..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm; ..\..\..\..\..\sdk\ble_stack\host\smp; ..\..\..\..\..\sdk\ble_stack\host\smp\smpc; ..\..\..\..\..\sdk\ble_stack\host\smp\smpm; ..\..\..\..\..\sdk\ble_stack\profiles; ..\..\..\..\..\sdk\ble_stack\profiles\anc; ..\..\..\..\..\sdk\ble_stack\profiles\anc\ancc\api; ..\..\..\..\..\sdk\ble_stack\profiles\anp; ..\..\..\..\..\sdk\ble_stack\profiles\anp\anpc\api; ..\..\..\..\..\sdk\ble_stack\profiles\anp\anps\api; ..\..\..\..\..\sdk\ble_stack\profiles\bas\basc\api; ..\..\..\..\..\sdk\ble_stack\profiles\bas\bass\api; ..\..\..\..\..\sdk\ble_stack\profiles\bcs; ..\..\..\..\..\sdk\ble_stack\profiles\bcs\bcsc\api; ..\..\..\..\..\sdk\ble_stack\profiles\bcs\bcss\api; ..\..\..\..\..\sdk\ble_stack\profiles\blp; ..\..\..\..\..\sdk\ble_stack\profiles\blp\blpc\api; ..\..\..\..\..\sdk\ble_stack\profiles\blp\blps\api; ..\..\..\..\..\sdk\ble_stack\profiles\bms; ..\..\..\..\..\sdk\ble_stack\profiles\bms\bmsc\api; ..\..\..\..\..\sdk\ble_stack\profiles\bms\bmss\api; ..\..\..\..\..\sdk\ble_stack\profiles\cpp; ..\..\..\..\..\sdk\ble_stack\profiles\cpp\cppc\api; ..\..\..\..\..\sdk\ble_stack\profiles\cpp\cpps\api; ..\..\..\..\..\sdk\ble_stack\profiles\cscp; ..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscpc\api; ..\..\..\..\..\sdk\ble_stack\profiles\cscp\cscps\api; ..\..\..\..\..\sdk\ble_stack\profiles\cts; ..\..\..\..\..\sdk\ble_stack\profiles\cts\ctsc\api; ..\..\..\..\..\sdk\ble_stack\profiles\cts\ctss\api; ..\..\..\..\..\sdk\ble_stack\profiles\custom; ..\..\..\..\..\sdk\ble_stack\profiles\custom\custs\api; ..\..\..\..\..\sdk\ble_stack\profiles\dis\disc\api; ..\..\..\..\..\sdk\ble_stack\profiles\dis\diss\api; ..\..\..\..\..\sdk\ble_stack\profiles\find; ..\..\..\..\..\sdk\ble_stack\profiles\find\findl\api; ..\..\..\..\..\sdk\ble_stack\profiles\find\findt\api; ..\..\..\..\..\sdk\ble_stack\profiles\gatt\gatt_client\api; ..\..\..\..\..\sdk\ble_stack\profiles\glp; ..\..\..\..\..\sdk\ble_stack\profiles\glp\glpc\api; ..\..\..\..\..\sdk\ble_stack\profiles\glp\glps\api; ..\..\..\..\..\sdk\ble_stack\profiles\hogp; ..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpbh\api; ..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogpd\api; ..\..\..\..\..\sdk\ble_stack\profiles\hogp\hogprh\api; ..\..\..\..\..\sdk\ble_stack\profiles\hrp; ..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrpc\api; ..\..\..\..\..\sdk\ble_stack\profiles\hrp\hrps\api; ..\..\..\..\..\sdk\ble_stack\profiles\htp; ..\..\..\..\..\sdk\ble_stack\profiles\htp\htpc\api; ..\..\..\..\..\sdk\ble_stack\profiles\htp\htpt\api; ..\..\..\..\..\sdk\ble_stack\profiles\lan; ..\..\..\..\..\sdk\ble_stack\profiles\lan\lanc\api; ..\..\..\..\..\sdk\ble_stack\profiles\lan\lans\api; ..\..\..\..\..\sdk\ble_stack\profiles\pasp; ..\..\..\..\..\sdk\ble_stack\profiles\pasp\paspc\api; ..\..\..\..\..\sdk\ble_stack\profiles\pasp\pasps\api; ..\..\..\..\..\sdk\ble_stack\profiles\prox\proxm\api; ..\..\..\..\..\sdk\ble_stack\profiles\prox\proxr\api; ..\..\..\..\..\sdk\ble_stack\profiles\rscp; ..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscpc\api; ..\..\..\..\..\sdk\ble_stack\profiles\rscp\rscps\api; ..\..\..\..\..\sdk\ble_stack\profiles\scpp; ..\..\..\..\..\sdk\ble_stack\profiles\scpp\scppc\api; ..\..\..\..\..\sdk\ble_stack\profiles\scpp\scpps\api; ..\..\..\..\..\sdk\ble_stack\profiles\suota\suotar\api; ..\..\..\..\..\sdk\ble_stack\profiles\tip; ..\..\..\..\..\sdk\ble_stack\profiles\tip\tipc\api; ..\..\..\..\..\sdk\ble_stack\profiles\tip\tips\api; ..\..\..\..\..\sdk\ble_stack\profiles\uds; ..\..\..\..\..\sdk\ble_stack\profiles\uds\udsc\api; ..\..\..\..\..\sdk\ble_stack\profiles\uds\udss\api; ..\..\..\..\..\sdk\ble_stack\profiles\wss; ..\..\..\..\..\sdk\ble_stack\profiles\wss\wssc\api; ..\..\..\..\..\sdk\ble_stack\profiles\wss\wsss\api; ..\..\..\..\..\sdk\ble_stack\rwble; ..\..\..\..\..\sdk\ble_stack\rwble_hl; ..\..\..\..\..\sdk\common_project_files; ..\..\..\..\..\sdk\platform\arch; ..\..\..\..\..\sdk\platform\arch\boot; ..\..\..\..\..\sdk\platform\arch\boot\ARM; ..\..\..\..\..\sdk\platform\arch\boot\GCC; ..\..\..\..\..\sdk\platform\arch\compiler; ..\..\..\..\..\sdk\platform\arch\compiler\ARM; ..\..\..\..\..\sdk\platform\arch\compiler\GCC; ..\..\..\..\..\sdk\platform\arch\ll; ..\..\..\..\..\sdk\platform\arch\main; ..\..\..\..\..\sdk\platform\core_modules\arch_console; ..\..\..\..\..\sdk\platform\core_modules\common\api; ..\..\..\..\..\sdk\platform\core_modules\crypto; ..\..\..\..\..\sdk\platform\core_modules\dbg\api; ..\..\..\..\..\sdk\platform\core_modules\gtl\api; ..\..\..\..\..\sdk\platform\core_modules\gtl\src; ..\..\..\..\..\sdk\platform\core_modules\h4tl\api; ..\..\..\..\..\sdk\platform\core_modules\ke\api; ..\..\..\..\..\sdk\platform\core_modules\ke\src; ..\..\..\..\..\sdk\platform\core_modules\nvds\api; ..\..\..\..\..\sdk\platform\core_modules\rf\api; ..\..\..\..\..\sdk\platform\core_modules\rwip\api; ..\..\..\..\..\sdk\platform\driver\adc; ..\..\..\..\..\sdk\platform\driver\battery; ..\..\..\..\..\sdk\platform\driver\ble; ..\..\..\..\..\sdk\platform\driver\dma; ..\..\..\..\..\sdk\platform\driver\gpio; ..\..\..\..\..\sdk\platform\driver\hw_otpc; ..\..\..\..\..\sdk\platform\driver\i2c; ..\..\..\..\..\sdk\platform\driver\i2c_eeprom; ..\..\..\..\..\sdk\platform\driver\pdm; ..\..\..\..\..\sdk\platform\driver\reg; ..\..\..\..\..\sdk\platform\driver\rtc; ..\..\..\..\..\sdk\platform\driver\spi; ..\..\..\..\..\sdk\platform\driver\spi_flash; ..\..\..\..\..\sdk\platform\driver\spi_hci; ..\..\..\..\..\sdk\platform\driver\syscntl; ..\..\..\..\..\sdk\platform\driver\systick; ..\..\..\..\..\sdk\platform\driver\timer; ..\..\..\..\..\sdk\platform\driver\trng; ..\..\..\..\..\sdk\platform\driver\uart; ..\..\..\..\..\sdk\platform\driver\wkupct_quadec; ..\..\..\..\..\sdk\platform\include; ..\..\..\..\..\sdk\platform\system_library\include; ..\..\..\..\..\third_party\hash; ..\..\..\..\..\third_party\irng; ..\..\..\..\..\third_party\rand; ..\src; ..\src\config; ..\..\..\..\..\sdk\platform\utilities\otp_cs; ..\..\..\..\..\sdk\platform\utilities\otp_hdr
  OBJCOPY.OOCOutputFile: prox_reporter_531.bin
  ILINK.IlinkOutputFile: prox_reporter_531.out
  ILINK.IlinkIcfFile: da14531.icf
  ILINK.IlinkExtraOptions: -f ..\..\..\..\..\sdk\common_project_files\misc\da14531_symbols.xcl
configuration DA14531_01 (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 35
  ICCARM.CCDefines: __DA14531__=; __DA14531_01__=
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: prox_reporter_531_01.bin
  ILINK.IlinkOutputFile: prox_reporter_531_01.out
  ILINK.IlinkIcfFile: da14531.icf
  ILINK.IlinkExtraOptions: -f ..\..\..\..\..\sdk\common_project_files\misc\da14531_01_symbols.xcl
configuration DA14535 (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 35
  ICCARM.CCDefines: __DA14531__=; __DA14535__=
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: prox_reporter_535.bin
  ILINK.IlinkOutputFile: prox_reporter_535.out
  ILINK.IlinkIcfFile: da14535.icf
  ILINK.IlinkExtraOptions: -f ..\..\..\..\..\sdk\common_project_files\misc\da14535_symbols.xcl
  group (top)
    ../../../../../sdk/platform/system_library/output/IAR/: da14531.a da14531_01.a da14535.a da14585_586.a
  group sdk_app
    ../../../../../sdk/app_modules/src/app_common/: app.c app_msg_utils.c app_task.c app_utils.c
    ../../../../../sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    ../../../../../sdk/app_modules/src/app_bond_db/: app_bond_db.c
    ../../../../../sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    ../../../../../sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    ../../../../../sdk/app_modules/src/app_easy/: app_easy_crypto.c app_easy_msg_utils.c app_easy_security.c app_easy_storage.c app_easy_timer.c
    ../../../../../sdk/app_modules/src/app_entry/: app_entry_point.c
    ../../../../../sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    ../../../../../sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    ../../../../../sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
  group sdk_arch
    ../../../../../sdk/platform/core_modules/arch_console/: arch_console.c
    ../../../../../sdk/platform/arch/main/: arch_hibernation.c arch_main.c arch_rom.c arch_sleep.c arch_system.c jump_table.c
    ../../../../../third_party/rand/: chacha20.c
    ../../../../../third_party/hash/: hash.c
    ../../../../../sdk/platform/core_modules/nvds/src/: nvds.c
    ../../../../../sdk/platform/utilities/otp_cs/: otp_cs.c
    ../../../../../sdk/platform/utilities/otp_hdr/: otp_hdr.c
    ../../../../../sdk/platform/system_library/src/DA14531/: system_library_531.c
    ../../../../../sdk/platform/system_library/src/DA14531_01/: system_library_531_01.c
    ../../../../../sdk/platform/system_library/src/DA14535/: system_library_535.c
    ../../../../../sdk/platform/system_library/src/DA14585_586/: system_library_585_586.c
  group sdk_ble
    ../../../../../sdk/platform/core_modules/rf/src/: ble_arp.c rf_531.c rf_585.c
    ../../../../../sdk/ble_stack/rwble/: rwble.c
    ../../../../../sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_boot
    ../../../../../sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
    ../../../../../sdk/platform/arch/boot/: startup_DA14531.c startup_DA14535.c startup_DA14585_586.c system_DA14531.c system_DA14535.c system_DA14585_586.c
  group sdk_driver
    ../../../../../sdk/platform/driver/adc/: adc_531.c adc_58x.c
    ../../../../../sdk/platform/driver/battery/: battery.c
    ../../../../../sdk/platform/driver/dma/: dma.c
    ../../../../../sdk/platform/driver/gpio/: gpio.c
    ../../../../../sdk/platform/driver/hw_otpc/: hw_otpc_531.c hw_otpc_58x.c
    ../../../../../sdk/platform/driver/i2c/: i2c.c
    ../../../../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ../../../../../sdk/platform/driver/rtc/: rtc.c
    ../../../../../sdk/platform/driver/spi/: spi_531.c spi_58x.c
    ../../../../../sdk/platform/driver/spi_flash/: spi_flash.c
    ../../../../../sdk/platform/driver/syscntl/: syscntl.c
    ../../../../../sdk/platform/driver/timer/: timer1.c
    ../../../../../sdk/platform/driver/trng/: trng.c
    ../../../../../sdk/platform/driver/uart/: uart.c
    ../../../../../sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
  group sdk_profiles
    ../../../../../sdk/ble_stack/profiles/bas/bass/src/: bass.c bass_task.c
    ../../../../../sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    ../../../../../sdk/ble_stack/profiles/: prf.c prf_utils.c
    ../../../../../sdk/ble_stack/profiles/prox/proxr/src/: proxr.c proxr_task.c
    ../../../../../sdk/ble_stack/profiles/suota/suotar/src/: suotar.c suotar_task.c
  group user_app
    ../src/: user_proxr.c
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_modules_config.h user_periph_setup.h user_profiles_config.h
  group user_config/da14531_config
    ../src/config/: da14531_config_advanced.h da14531_config_basic.h
  group user_config/da14535_config
    ../src/config/: da14535_config_advanced.h da14535_config_basic.h
  group user_config/da14585-6_config
    ../src/config/: da14585_config_advanced.h da14585_config_basic.h
  group user_platform
    ../src/platform/: user_periph_setup.c
